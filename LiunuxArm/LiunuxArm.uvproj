# Keil uVision project LiunuxArm.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: S3C2410A Samsung
  cpu: IRAM(0x40000000-0x40001FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: LiunuxArm
  c flags: Optim=1
  memory RVCT9: RAM 0x40000000 size 0x2000
  group Source Group 1
    ./: boot.s abt.c fiq.c irq.c swi.c undef.c reset.c interruption.s memory.s uart.s mem_init.cpp
